# Repository LuZening/OPA1000

## KiCad design RF/Overdrive_Protector/Overdrive_Rev_Protector/Overdrive_Rev_Protector.kicad_pcb

Parts:
C1, C7: 10uF; 0805_C
C2, C4, C6, C8, C9, C13, C14: 104; 0805_C
C3, C5, C15: 103; 0805_C
C11, C12: 1nF; 0805_C
D1, D2, D4, D5, D7, D9, D10, D11, D12, D13: 4148; SOD-123
D3: Red; LED_0805_HandSoldering
D6, D8: ESD; SOD-323
FB1: Ferrite_Bead; 1206_L
J1: Current; JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
J2: 12Vin; JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
J3: Fault; JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
J4: REV; JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
J5: Conn_01x03; JST_PH_S3B-PH-SM4-TB_03x2.00mm_Angled
J6: Fault Out; JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled
J7: Bias; Measurement_Point_Square-SMD-Pad_Big
K1: G6K-2; HFD4S
Q1: 8550; SOT-23(SOT-23-3)
Q2: 8050; SOT-23
R1, R3, R7, R10: 10K; 0805_R
R2, R11, R15, R17, R19, R23: 1K; 0805_R
R4: 20K; 0805_R
R5, R6: 1M; 0805_R
R8: 7.5K; 0805_R
R9: 2.7K; 0805_R
R12, R13: 4.7K; 0805_R
R14, R16: 0; 1206_R
R20: 0; 0201
R21, R22: 5.1K; 0805_R
RV1, RV2: 10K; Potentiometer_Trimmer_Bourns_3296W
U1: L78L05_SOT89; SOT-89(SOT-89-3)
U2: LMV321 IORR; SOT-23-5
U3: LMV358 IORR; SOIC-8_150MIL
U4: LM358; SOIC-8_150MIL

Connections:
+5V: C7.1, C8.2, C9.2, Q1.2 (E), R4.2, R7.1, U1.1 (OUT), U2.5 (V+), U3.8 (V+)
+12V: C1.1, C4.1, C15.2, D10.2 (K), D11.2 (K), FB1.1, R21.2, U1.3 (IN), U4.8 (V+)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.1, C9.1, C11.2, C12.2, C13.1, C14.1, C15.1, D5.1 (A), J1.2, J2.2, J3.2, J4.2, J6.2, K1.8, Q2.2 (E), R5.1, R6.1, R10.1, R12.1, R20.2, R22.1, RV1.1, U1.2 (GND), U2.2 (V-), U3.4 (V-), U4.4 (V-)
GNDPWR: D6.2 (A2), D8.1 (A1), J5.2, K1.3, K1.6, R20.1
unnamed: C2.1, R2.1, U2.1 (+)
unnamed: C3.1, D1.2 (K), R1.1, R5.2, U3.3 (+)
unnamed: C5.1, D2.2 (K), R3.1, R6.2, U3.6 (-)
unnamed: C6.2, RV1.2, U2.3 (-)
unnamed: C11.1, D7.2 (K), R19.2
unnamed: C12.1, D9.2 (K), R23.2
unnamed: C13.2, J7.1, Q2.3 (C)
unnamed: C14.2, RV2.2, U4.2 (-), U4.6 (-)
unnamed: D3.1 (K), R12.2
unnamed: D3.2 (A), D5.2 (K), K1.1, Q1.3 (C)
unnamed: D4.1 (A), U2.4
unnamed: D6.1 (A1), D7.1 (A), J5.1, R14.2
unnamed: D8.2 (A2), D9.1 (A), J5.3, R16.1
unnamed: D10.1 (A), R23.1, U4.5 (+)
unnamed: D11.1 (A), R19.1, U4.3 (+)
unnamed: D12.1 (A), U4.1
unnamed: D13.1 (A), U4.7
unnamed: FB1.2, J2.1
unnamed: J1.1, R1.2
unnamed: J3.1, R3.2
unnamed: J4.1, R2.2
unnamed: J6.1, R15.1
unnamed: K1.4, R14.1
unnamed: K1.5, R16.2
unnamed: Q1.1 (B), R13.2
unnamed: Q2.1 (B), R17.1
unnamed: R4.1, RV1.3
unnamed: R7.2, R8.2
unnamed: R8.1, R9.2, U3.2 (-)
unnamed: R9.1, R10.2, U3.5 (+)
unnamed: R11.1, U3.1
unnamed: R13.1, U3.7
unnamed: R21.1, RV2.3
unnamed: R22.2, RV2.1

Notes on the sheet:
1.9V for 32A/100A
0.75V = 200W rev
Fast Bias Down
CW:2->3

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
Board: 2 copper layers, 54.5 x 39.5 mm, 66 parts (0 on the bottom side), 39 nets.

File RF/Overdrive_Protector/Overdrive_Rev_Protector/Overdrive_Rev_Protector_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"1nF","desc","C12,C11,","0805_C","libref","2","2","","",
"104","desc","C14,C13,C9,C8,C6,C5,C4,C3,C2,","0805_C","libref","2","9","","",
"103","desc","C15,","0805_C","libref","2","1","","",
"10uF","desc","C7,C1,","0805_C","libref","2","2","","",
"4148","desc","D13,D12,D11,D10,D9,D7,D5,D4,D2,D1,","SOD-123","libref","2","10","","",
"Red","desc","D3,","LED_0805_HandSoldering","libref","2","1","","",
"ESD","desc","D8,D6,","SOD-323","libref","2","2","","",
"Ferrite_Bead","desc","FB1,","1206_L","libref","2","1","","",
"Current","desc","J1,","JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled","libref","4","1","","",
"12Vin","desc","J2,","JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled","libref","4","1","","",
"Fault","desc","J3,","JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled","libref","4","1","","",
"REV","desc","J4,","JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled","libref","4","1","","",
"Conn_01x03","desc","J5,","JST_PH_S3B-PH-SM4-TB_03x2.00mm_Angled","libref","5","1","","",
"Fault Out","desc","J6,","JST_PH_S2B-PH-SM4-TB_02x2.00mm_Angled","libref","4","1","","",
"Bias","desc","J7,","Measurement_Point_Square-SMD-Pad_Big","libref","1","1","","",
"G6K-2","desc","K1,","HFD4S","libref","8","1","","",
"8550","desc","Q1,","SOT-23(SOT-23-3)","libref","3","1","","",
"8050","desc","Q2,","SOT-23","libref","3","1","","",
"10K","desc","R10,","0805_R","libref","2","1","","",
"4.7K","desc","R13,R12,","0805_R","libref","2","2","","",
"0","desc","R16,R14,","1206_R","libref","2","2","","",
"0","desc","R20,","0201","libref","2","1","","",
"5.1K","desc","R22,R21,","0805_R","libref","2","2","","",
"1K","desc","R23,R19,R17,R15,R11,R3,R2,R1,","0805_R","libref","2","8","","",
"20K","desc","R4,","0805_R","libref","2","1","","",
"100K","desc","R6,R5,","0805_R","libref","2","2","","",
"0","desc","R7,","0805_R","libref","2","1","","",
"7.5K","desc","R8,","0805_R","libref","2","1","","",
"2.7K","desc","R9,","0805_R","libref","2","1","","",
"L78L05_SOT89","desc","U1,","SOT-89(SOT-89-3)","libref","4","1","","",
"LMV321","desc","U2,","SOT-23-5","libref","5","1","","",
"LM358","desc","U4,U3,","SOIC-8_150MIL","libref","8","2","","",
"Through Hole Items ",
"10K","desc","RV2,RV1,","Potentiometer_Trimmer_Bourns_3296W","libref","3","2","","",

## KiCad design MCU/MCU_2/MCU.kicad_pcb

Parts:
C1, C2: C_Small; C_0805
C3, C4, C5, C6, C7, C8, C9, C10, C12, C57, C58, C59: 104; C_0805
C11: 10uF; C_0805
D24: LED; LED_0805
D26: SD103; SOD-123
J1, J2: Conn_01x08; JST_XH_B08B-XH-A_08x2.50mm_Straight
J3: Conn_02x20_Odd_Even; Socket_Strip_Straight_2x20_Pitch2.54mm
J4: Conn_01x04; Pin_Header_Straight_1x04_Pitch2.54mm
L1, L2, L3: 600Ohm; L_0805
Q1: 8050; SOT-23(SOT-23-3)
R1, R2, R3, R4, R5, R6, R14: 10K; R_0805
R7, R8, R9, R10, R11, R12, R13, R84: 4.7K; R_0805
U1: 74HC04; SOIC-14_150MIL
U2: STM32F407VETx; LQFP-100_14X14X05P
Y1: 12MHz; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
+3V3: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, D24.2 (A), L1.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, U1.14 (VCC), U2.6 (VBAT), U2.11 (VDD), U2.19 (VDD), U2.28 (VDD), U2.50 (VDD), U2.75 (VDD), U2.100 (VDD); also elsewhere on the board
+12V: J2.8; also elsewhere on the board
/ADC1_3: U2.26 (PA3); also elsewhere on the board
/ADC1_4: U2.29 (PA4); also elsewhere on the board
/ADC1_5: U2.30 (PA5); also elsewhere on the board
/ADC1_6: U2.31 (PA6); also elsewhere on the board
/ADC1_7: U2.32 (PA7); also elsewhere on the board
/ADC1_8: U2.35 (PB0); also elsewhere on the board
/ADC1_9: U2.36 (PB1); also elsewhere on the board
/ADC1_14: U2.33 (PC4); also elsewhere on the board
/ADC3_1: U2.24 (PA1); also elsewhere on the board
/ADC3_10: U2.15 (PC0); also elsewhere on the board
/ADC3_11: U2.16 (PC1); also elsewhere on the board
/ADC3_12: U2.17 (PC2); also elsewhere on the board
/ADC3_13: U2.18 (PC3); also elsewhere on the board
/BL: J3.37, U2.47 (PB10)
/CAN_RX: U2.51 (PB12); also elsewhere on the board
/CAN_TX: U2.52 (PB13); also elsewhere on the board
/CS: J3.12, U2.88 (PD7)
/D0: J3.15, U2.61 (PD14)
/D1: J3.18, U2.62 (PD15)
/D2: J3.17, U2.81 (PD0)
/D3: J3.20, U2.82 (PD1)
/D4: J3.19, U2.38 (PE7)
/D5: J3.22, U2.39 (PE8)
/D6: J3.21, U2.40 (PE9)
/D7: J3.24, U2.41 (PE10)
/D8: J3.23, U2.42 (PE11)
/D9: J3.26, U2.43 (PE12)
/D10: J3.25, U2.44 (PE13)
/D11: J3.28, U2.45 (PE14)
/D12: J3.27, U2.46 (PE15)
/D13: J3.30, U2.55 (PD8)
/D14: J3.29, U2.56 (PD9)
/D15: J3.32, U2.57 (PD10)
/D16: J3.9
/D17: J3.10
/D18: J3.7
/D19: J3.8
/D20: J3.5
/D21: J3.6
/D22: J3.3
/D23: J3.4
/ExternalInput/PTT_RTS: R14.2; also elsewhere on the board
/FaultHandling/Clear_Fault: D26.1 (A); also elsewhere on the board
/MCU_STATE: R84.1, U2.23 (PA0)
/NRST: C3.1, J4.1, U2.14 (NRST)
/RD: J3.13, U2.85 (PD4)
/RESX: J3.16, U2.63 (PC6)
/RS: J3.11, U2.60 (PD13)
/RX: L3.1; also elsewhere on the board
/RX2: U2.87 (PD6)
/SWCLK: J4.2, U2.76 (PA14)
/SWDIO: J4.3, U2.72 (PA13)
/TX: L2.1; also elsewhere on the board
/TX2: U2.25 (PA2)
/T_BUSY: J3.31, U2.95 (PB8)
/T_CS: J3.34, U2.96 (PB9)
/T_INT: J3.38, U2.48 (PB11)
/T_MISO: J3.36, U2.90 (PB4)
/T_MOSI: J3.35, U2.91 (PB5)
/T_SCK: J3.33, U2.89 (PB3)
/WR: J3.14, U2.86 (PD5)
/X1: C1.1, U2.12 (PH0), Y1.1
/X2: C2.1, U2.13 (PH1), Y1.3
ALC_trig: U2.70 (PA11); also elsewhere on the board
AUTO_BAND: J1.7, U2.8 (PC14)
Clear_fault: D26.2 (K), U2.67 (PA8)
FAN1: U2.83 (PD2); also elsewhere on the board
FAN2: U2.84 (PD3); also elsewhere on the board
GND: C10.2, C11.2, C12.2, C59.2, J1.8, J2.1, Q1.2 (E), U1.7 (GND), U2.20 (VSSA); also elsewhere on the board
GNDD: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C57.2, C58.2, J3.1, J3.40, J4.4, R13.2, U2.10 (VSS), U2.27 (VSS), U2.74 (VSS), U2.99 (VSS), Y1.2, Y1.4; also elsewhere on the board
Im_HIGH: U2.79 (PC11); also elsewhere on the board
unnamed: C12.1, Q1.1 (B), R14.1
unnamed: C57.1, U2.49 (VCAP_1)
unnamed: C58.1, U2.73 (VCAP_2)
unnamed: D24.1 (K), R84.2
unnamed: J2.2, R12.1
unnamed: J2.3, R11.1
unnamed: J2.4, R10.2
unnamed: J2.5, R9.2
unnamed: J2.6, R8.1
unnamed: J2.7, R7.1
unnamed: L2.2, U2.68 (PA9)
unnamed: L3.2, U2.69 (PA10)
unnamed: R7.2, U1.2
unnamed: R8.2, U1.4
unnamed: R9.1, U1.6
unnamed: R10.1, U1.12
unnamed: R11.2, U1.10
unnamed: R12.2, U1.8
unnamed: R13.1, U2.94 (BOOT0)
Overdrive: U2.98 (PE1); also elsewhere on the board
PTT: Q1.3 (C); also elsewhere on the board
PWR_on_sig: U2.97 (PE0); also elsewhere on the board
REV1_HIGH: U2.93 (PB7); also elsewhere on the board
REV2_HIGH: U2.92 (PB6); also elsewhere on the board
SEL1: J1.1, R6.2, U1.1, U2.7 (PC13)
SEL2: J1.2, R5.2, U1.3, U2.5 (PE6)
SEL3: J1.3, R4.2, U1.5, U2.4 (PE5)
SEL4: J1.4, R3.2, U1.13, U2.3 (PE4)
SEL5: J1.5, R2.2, U1.11, U2.2 (PE3)
SEL6: J1.6, R1.2, U1.9, U2.1 (PE2)
Temp1_HIGH: U2.78 (PC10); also elsewhere on the board
Temp2_HIGH: U2.77 (PA15); also elsewhere on the board
Transmit: U2.71 (PA12); also elsewhere on the board
VBL: J3.39; also elsewhere on the board
VDDA: C10.1, C11.1, C59.1, L1.1, U2.21 (VREF+), U2.22 (VDDA)
Vm_HIGH: U2.80 (PC12); also elsewhere on the board

Notes on the sheet:
LOW EFFECTIVE
A18
Back light HIGH Effective
Low to turn on

Parts:
C13, C14, C15, C16, C17, C18, C19, C20, C24, C25, C26, C27, C28, C29, C30, C31, C32: 104; C_0805
C21, C22, C23: C_Small; C_0805
J5: Conn_01x04; JST_XH_B04B-XH-A_04x2.50mm_Straight
J6, J7, J10: Conn_01x02; JST_XH_B02B-XH-A_02x2.50mm_Straight
J8, J9: Conn_01x06; JST_XH_B06B-XH-A_06x2.50mm_Straight
R15, R18, R19, R20, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R41: 1K; R_0805
R16, R21: 2.2K; R_0805
R17: 8.2K; R_0805
R39, R40: 3.3K; R_0805
R42: 22K; R_0805
RV1: 10K; 3362P
U3, U4, U6, U7: LMV324; SOIC-14_150MIL
U5: LMV358; SOIC-8_150MIL
U8: LMV321; SOT-23-5

Connections:
+3V3: C13.1, C14.1, C21.1, C22.1, C23.1, R16.2, R19.2, R21.2, R24.2, R27.2, R29.2, RV1.1, U3.4 (V+), U4.4 (V+), U5.8 (V+), U6.4 (V+), U7.4 (V+), U8.5 (V+); also elsewhere on the board
+5V: J8.6, J9.6, R39.2, R40.2; also elsewhere on the board
/ADC1_3: U7.6 (-), U7.7; also elsewhere on the board
/ADC1_4: U7.1, U7.2 (-); also elsewhere on the board
/ADC1_5: U5.3 (+), U7.8, U7.9 (-); also elsewhere on the board
/ADC1_6: U7.13 (-), U7.14; also elsewhere on the board
/ADC1_7: U6.6 (-), U6.7; also elsewhere on the board
/ADC1_8: U6.1, U6.2 (-); also elsewhere on the board
/ADC1_9: U5.5 (+), U6.8, U6.9 (-); also elsewhere on the board
/ADC1_14: U6.13 (-), U6.14; also elsewhere on the board
/ADC3_10: U3.1, U3.2 (-), U3.5 (+); also elsewhere on the board
/ADC3_11: U3.8, U3.9 (-), U3.12 (+); also elsewhere on the board
/ADC3_12: U4.1, U4.2 (-), U4.6 (-); also elsewhere on the board
/ADC3_13: U4.8, U4.9 (-), U4.13 (-); also elsewhere on the board
FWD1: J8.4, R36.1
FWD2: J9.4, R32.1
FWDpeak1: J8.5, R35.1
FWDpeak2: J9.5, R31.1
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, J5.4, J6.2, J7.2, J8.1, J9.1, J10.2, R17.1, R20.1, R22.1, R25.1, R28.1, R30.1, R41.1, RV1.3, U3.11 (V-), U4.11 (V-), U5.4 (V-), U6.11 (V-), U7.11 (V-), U8.2 (V-); also elsewhere on the board
Im_HIGH: U3.14; also elsewhere on the board
Im_sense: J5.2, R18.1
unnamed: C15.1, R15.2, U3.3 (+)
unnamed: C16.1, R18.2, U3.10 (+)
unnamed: C17.1, R26.2, U4.3 (+)
unnamed: C18.1, R23.2, U4.10 (+)
unnamed: C19.1, R24.1, R25.2, U4.12 (+)
unnamed: C20.1, R21.1, R22.2, U4.5 (+)
unnamed: C24.1, R31.2, U6.3 (+)
unnamed: C25.1, R32.2, U6.5 (+)
unnamed: C26.1, R33.2, U6.10 (+)
unnamed: C27.1, R34.2, U6.12 (+)
unnamed: C28.1, R35.2, U7.3 (+)
unnamed: C29.1, R36.2, U7.5 (+)
unnamed: C30.1, R37.2, U7.10 (+)
unnamed: C31.1, R38.2, U7.12 (+)
unnamed: C32.1, R41.2, R42.2, U8.1 (+)
unnamed: R16.1, R17.2, U3.6 (-)
unnamed: R19.1, R20.2, U3.13 (-)
unnamed: R27.1, R28.2, U5.2 (-)
unnamed: R29.1, R30.2, U5.6 (-)
unnamed: RV1.2, U8.3 (-)
Overdrive: U8.4; also elsewhere on the board
PWR_on: J5.3; also elsewhere on the board
REV1: J8.2, R38.1
REV1_HIGH: U5.1; also elsewhere on the board
REV2: J9.2, R34.1
REV2_HIGH: U5.7; also elsewhere on the board
REVpeak1: J8.3, R37.1
REVpeak2: J9.3, R33.1
RF_in_level: J10.1, R42.1
Temp1: J6.1, R26.1, R40.1
Temp1_HIGH: U4.7; also elsewhere on the board
Temp2: J7.1, R23.1, R39.1
Temp2_HIGH: U4.14; also elsewhere on the board
Vm_HIGH: U3.7; also elsewhere on the board
Vm_sense: J5.1, R15.1

Notes on the sheet:
Power Enable Signal Low Effect
NTC
Approx 70C
Approx 50C
Limit ADC at 2.6V Approx. Vmain=58.5V

Parts:
C34: 10nF; C_0805
C35, C36: 10uF; C_0805
C38: 1nF; C_0805
D12: SD103; SOD-123
J11, J12: Conn_01x02; JST_XH_B02B-XH-A_02x2.50mm_Straight
J13: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
Q2, Q3, Q5: 8050; SOT-23(SOT-23-3)
Q4: 8550; SOT-23(SOT-23-3)
R45: 4.7K; R_0805
R48, R51: 10K; R_0805
R50: 220; R_0805
R52: 3.3K; R_0805
R53: 8.2K; R_0805
R81: 100K; R_0805
U9: ICL7660; SOIC-8_150MIL
U11: PC817; DIP-4

Connections:
+3V3: Q4.2 (E), R52.1, U9.8 (V+), U11.1; also elsewhere on the board
+12V: J11.1, J12.1; also elsewhere on the board
/OutputSignals/REL_IN: J11.2, Q2.3 (C)
/OutputSignals/REL_OUT: J12.2, Q3.3 (C)
ALC: J13.1, R45.1, U11.3
ALC_trig: Q5.3 (C), R50.1; also elsewhere on the board
Fault_Low: D12.2 (K); also elsewhere on the board
GND: C34.2, C36.1, C38.2, J13.2, Q2.2 (E), Q3.2 (E), Q5.2 (E), R81.2, U9.3 (GND), U9.6 (LV), U11.4; also elsewhere on the board
unnamed 88: C38.1, Q5.1 (B), R53.1; also elsewhere on the board
unnamed 105: Q2.1 (B); also elsewhere on the board
unnamed: C35.1, U9.2 (CAP+)
unnamed: C35.2, U9.4 (CAP-)
unnamed: C36.2, R45.2, U9.5 (VOUT)
unnamed: Q4.1 (B), R51.1
unnamed: Q4.3 (C), R48.2
unnamed: R50.2, U11.2
PTT: R51.2, R52.2; also elsewhere on the board

Notes on the sheet:
T/R relays
Output Relay
Input Relay
Input Relay Delay
Supress ALC Negative Volt
Open Collector
22ms
Discharge

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C39: 102; C_0805
D1, D2, D3, D4, D5, D6, D7: D; LL-34
D15: T1H; LED_0805
D16: T2H; LED_0805
D17: VmH; LED_0805
D18: ImH; LED_0805
D19: R1H; LED_0805
D20: R2H; LED_0805
D21: OD; LED_0805
Q6, Q8: 8550; SOT-23(SOT-23-3)
Q7, Q9: 8050; SOT-23(SOT-23-3)
R54, R58: 1K; R_0805
R55: 10; R_0805
R56, R82, R83: 10K; R_0805
R57: 100K; R_0805
R59: 3.3K; R_0805
R73, R74, R75, R76, R77, R78, R79: 2.2K; R_0805

Connections:
+3V3: BZ1.1 (-), Q6.2 (E), Q8.2 (E); also elsewhere on the board
/FaultHandling/Clear_Fault: C39.1, Q9.1 (B), R58.2, R59.2; also elsewhere on the board
Fault_Low: BZ1.2 (+), Q9.3 (C), R57.2; also elsewhere on the board
GND: C39.2, D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), Q7.2 (E), Q9.2 (E), R58.1, R82.2; also elsewhere on the board
Im_HIGH: D4.1 (A), R76.2; also elsewhere on the board
unnamed: D1.2 (K), D2.2 (K), D3.2 (K), D4.2 (K), D5.2 (K), D6.2 (K), D7.2 (K), Q8.3 (C), R56.2, R59.1
unnamed: D15.2 (A), R73.1
unnamed: D16.2 (A), R74.1
unnamed: D17.2 (A), R75.1
unnamed: D18.2 (A), R76.1
unnamed: D19.2 (A), R77.1
unnamed: D20.2 (A), R78.1
unnamed: D21.2 (A), R79.1
unnamed: Q6.1 (B), R54.2
unnamed: Q6.3 (C), R83.1
unnamed: Q7.1 (B), R56.1
unnamed: Q8.1 (B), R57.1
Overdrive: D7.1 (A), R79.2; also elsewhere on the board
PWR_on: Q7.3 (C), R55.2, R82.1, R83.2; also elsewhere on the board
PWR_on_sig: R54.1; also elsewhere on the board
REV1_HIGH: D5.1 (A), R77.2; also elsewhere on the board
REV2_HIGH: D6.1 (A), R78.2; also elsewhere on the board
SW_PWR: R55.1; also elsewhere on the board
Temp1_HIGH: D1.1 (A), R73.2; also elsewhere on the board
Temp2_HIGH: D2.1 (A), R74.2; also elsewhere on the board
Vm_HIGH: D3.1 (A), R75.2; also elsewhere on the board

Notes on the sheet:
Low to Turnon
High Effective
Close to Turn off
Low to clear
Remove To disable fault auto power off

Parts:
C40, C52, C53, C54, C55, C56, C60: 104; C_0805
D13, D14: LED; LED_0805
D25: SD103; SOD-123
FB1, FB2, FB3, FB5, FB6: 1K; R_0805
J14, J15, J16, J18: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
J17: Conn_01x04; JST_XH_B04B-XH-A_04x2.50mm_Straight
J20: CAN; JST_XH_B02B-XH-A_02x2.50mm_Straight
R60, R61, R72: 1K; R_0805
R62, R85, R86: 100; R_0805
R87: 120; R_0805
U15: LMV321; SOT-23-5
U16: MAX3232; SOIC-16_150MIL
U17: TJA1042T; SOIC-8_150MIL

Connections:
+3V3: C53.1, C56.2, R60.2, R61.2, U15.5 (V+), U16.16 (VCC); also elsewhere on the board
+5VA: C60.2, U17.3 (VCC); also elsewhere on the board
/ADC3_1: U15.3 (-), U15.4; also elsewhere on the board
/CAN_RX: R86.2; also elsewhere on the board
/CAN_TX: R85.2; also elsewhere on the board
/ExternalInput/PTT_RTS: D25.2 (K); also elsewhere on the board
/ExternalInput/RX232: FB5.2, J17.3
/ExternalInput/TX232: FB6.2, J17.2
/RX: D14.1 (K), U16.12 (R1OUT); also elsewhere on the board
/TX: D13.1 (K), U16.11 (T1IN); also elsewhere on the board
CAN+: J20.2, R87.1, U17.7 (CANH)
CAN-: J20.1, R87.2, U17.6 (CANL)
GND: C40.1, C60.1, J14.2, J15.1, J16.1, J18.2, R72.1, U15.2 (V-), U17.2 (GND), U17.8 (STB); also elsewhere on the board
GNDD: C53.2, C55.1, J17.4, U16.15 (GND); also elsewhere on the board
unnamed: C40.2, R62.2, R72.2, U15.1 (+)
unnamed: C52.1, U16.1 (C1+)
unnamed: C52.2, U16.3 (C1-)
unnamed: C54.1, U16.5 (C2-)
unnamed: C54.2, U16.4 (C2+)
unnamed: C55.2, U16.6 (VS-)
unnamed: C56.1, U16.2 (VS+)
unnamed: D13.2 (A), R60.1
unnamed: D14.2 (A), R61.1
unnamed: D25.1 (A), J17.1
unnamed: FB1.1, J14.1
unnamed: FB2.2, J15.2
unnamed: FB3.2, J16.2
unnamed: FB5.1, U16.14 (T1OUT)
unnamed: FB6.1, U16.13 (R1IN)
unnamed: J18.1, R62.1
unnamed: R85.1, U17.1 (TXD)
unnamed: R86.1, U17.4 (RXD)
PTT: FB1.2; also elsewhere on the board
SW_Bypass: FB3.1; also elsewhere on the board
SW_PWR: FB2.1; also elsewhere on the board

Notes on the sheet:
Power On
Bypass
TX GND
PTT RTS
Band
RTS IS HIGH EFFECTIVE
