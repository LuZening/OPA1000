# Repository LuZening/OPA1000 (continued)

## KiCad design MCU/MCU_2/MCU.kicad_pcb (continued)

Parts:
C41, C47, C48: 104; C_0805
C42: 10u; CP_Radial_D5.0mm_P2.50mm
C43: 10nF NP0; C_0805
C44: 47pF; C_0805
C45, C49, C50: 10uF; C_0805
C46, C51: 25V 47uF; CP_Radial_D5.0mm_P2.50mm
D8: 16V; LL-34
D9, D10: SS14; SMA(DO-214AC)_S1
D22: Power; LED_0805
F1: 3A; R_1206
FB7: GND; R_1206
J19: Barrel_Jack_Switch; BARREL_JACK
L4: BEAD; L_1206
L5: 22uH; L_SMD4030_hand
M1, M2: Fan; JST_XH_B02B-XH-A_02x2.50mm_Straight
Q10, Q11: AO3402; SOT-23(SOT-23-3)
R63, R64, R67: 100K; R_0805
R65, R70: 100; R_0805
R66, R69: 10K; R_0805
R68: 16K; R_0805
R71: 0; R_1206
R80: 2.2K; R_0805
SC1, SC2, SC3, SC4, SC5, SC6, SC7, SC8: GND; M3_Screwhole
U12: SY8303; TSOT-23-8_HandSoldering
U13, U14: AZ1117-3.3; SOT-223

Connections:
+3V3: C49.1, R66.1, R69.1, U13.2 (VO); also elsewhere on the board
+5V: C44.1, C45.1, C47.1, L5.2, R67.1, R71.2, R80.2; also elsewhere on the board
+5VA: C48.1, R71.1, U13.3 (VI), U14.3 (VI); also elsewhere on the board
+12V: C46.1, C51.1, D8.2 (K), D9.2 (K), D10.2 (K), F1.2, L4.1, M1.1 (+), M2.1 (+); also elsewhere on the board
FAN1: R65.2; also elsewhere on the board
FAN2: R70.1; also elsewhere on the board
GND: C41.2, C42.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, D8.1 (A), D22.1 (K), FB7.1, J19.2, J19.3, Q10.2 (S), Q11.2 (S), R64.2, R68.2, SC1.1, SC2.1, SC3.1, SC4.1, SC5.1, SC6.1, SC7.1, SC8.1, U12.3, U12.4, U13.1 (GND), U14.1 (GND); also elsewhere on the board
GNDD: FB7.2; also elsewhere on the board
unnamed: C41.1, C42.1, L4.2, R63.1, U12.5
unnamed: C43.1, L5.1, U12.6
unnamed: C43.2, U12.7
unnamed: C44.2, R67.2, R68.1, U12.1
unnamed: D9.1 (A), M1.2 (-), Q10.3 (D)
unnamed: D10.1 (A), M2.2 (-), Q11.3 (D)
unnamed: D22.2 (A), R80.1
unnamed: F1.1, J19.1
unnamed: Q10.1 (G), R65.1, R66.2
unnamed: Q11.1 (G), R69.2, R70.2
unnamed: R63.2, U12.8
unnamed: R64.1, U12.2
VBL: C50.1, U14.2 (VO); also elsewhere on the board

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
Board: 2 copper layers, 130.0 x 100.0 mm, 246 parts (237 on the bottom side), 199 nets.

Other parts of the board:
47K1: R_Small; R_0805
C33: C_Small; C_0805
C37: 10uF; C_0805
D11, D23: SD103; SOD-123
R43, R44: 1K; R_0805
R46: 33k; R_0805
R47: 68K; R_0805
R49: 10K; R_0805
U10: LMV321; SOT-23-5

Their connections:
+3V3: R46.2, U10.5; also elsewhere on the board
GND: C33.2, C37.2, R47.2, R49.1, U10.2; also elsewhere on the board
unnamed 88: 47K1.1; also elsewhere on the board
unnamed 105: C33.1, R43.2; also elsewhere on the board
unnamed: C37.1, D23.2, R49.2, U10.1
unnamed: R46.1, R47.1, U10.3
SW_Bypass: D11.2; also elsewhere on the board
Transmit: 47K1.2, R43.1, U10.4; also elsewhere on the board

File MCU/MCU/MCU_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"C_Small","desc","C34,C33,C23,C22,C21,C2,C1,","C_0805","libref","2","7","","",
"1nF","desc","C38,","C_0805","libref","2","1","","",
"102","desc","C39,","C_0805","libref","2","1","","",
"10nF NP0","desc","C43,","C_0805","libref","2","1","","",
"47pF","desc","C44,","C_0805","libref","2","1","","",
"10uF","desc","C50,C49,C45,C37,C36,C35,C11,","C_0805","libref","2","7","","",
"104","desc","C60,C59,C58,C57,C56,C55,C54,C53,C52,C48,C47,C41,C40,C32,C31,C30,C29,C28,C27,C26,C25,C24,C20,C19,C18,C17,C16,C15,C14,C13,C12,C10,C9,C8,C7,C6,C5,C4,C3,","C_0805","libref","2","39","","",
"SS14","desc","D10,D9,","SMA(DO-214AC)_S1","libref","2","2","","",
"T1H","desc","D15,","LED_0805","libref","2","1","","",
"T2H","desc","D16,","LED_0805","libref","2","1","","",
"VmH","desc","D17,","LED_0805","libref","2","1","","",
"ImH","desc","D18,","LED_0805","libref","2","1","","",
"R1H","desc","D19,","LED_0805","libref","2","1","","",
"R2H","desc","D20,","LED_0805","libref","2","1","","",
"OD","desc","D21,","LED_0805","libref","2","1","","",
"Power","desc","D22,","LED_0805","libref","2","1","","",
"LED","desc","D24,D14,D13,","LED_0805","libref","2","3","","",
"SD103","desc","D26,D25,D23,D12,D11,","SOD-123","libref","2","5","","",
"D","desc","D7,D6,D5,D4,D3,D2,D1,","LL-34","libref","2","7","","",
"16V","desc","D8,","LL-34","libref","2","1","","",
"2A","desc","F1,","R_1206","libref","2","1","","",
"1K","desc","FB6,FB5,FB3,FB2,FB1,R72,R61,R60,R58,R54,R44,R43,R41,R40,R39,R38,R37,R36,R35,R34,R33,R32,R31,R30,R29,R28,R27,R26,R25,R24,R23,R22,R21,R20,R19,R18,R17,R16,R15,","R_0805","libref","2","39","","",
"1K","desc","FB7,","R_1206","libref","2","1","","",
"600Ohm","desc","L3,L2,L1,","L_0805","libref","2","3","","",
"BEAD","desc","L4,","L_1206","libref","2","1","","",
"22uH","desc","L5,","L_SMD4030_hand","libref","2","1","","",
"AO3402","desc","Q11,Q10,","SOT-23(SOT-23-3)","libref","3","2","","",
"8550","desc","Q6,Q8,Q4,","SOT-23(SOT-23-3)","libref","3","3","","",
"8050","desc","Q9,Q7,Q5,Q3,Q2,Q1,","SOT-23(SOT-23-3)","libref","3","6","","",
"22K","desc","R42,","R_0805","libref","2","1","","",
"33k","desc","R46,","R_0805","libref","2","1","","",
"68K","desc","R47,","R_0805","libref","2","1","","",
"47K","desc","R51,","R_0805","libref","2","1","","",
"10","desc","R55,","R_0805","libref","2","1","","",
"3.3K","desc","R59,","R_0805","libref","2","1","","",
"100K","desc","R67,R64,R63,R57,R52,","R_0805","libref","2","5","","",
"16K","desc","R68,","R_0805","libref","2","1","","",
"0","desc","R71,","R_1206","libref","2","1","","",
"2.2K","desc","R80,R79,R78,R77,R76,R75,R74,R73,R50,","R_0805","libref","2","9","","",
"R_Small","desc","R81,47K1,","R_0805","libref","2","2","","",
"10K","desc","R83,R82,R69,R66,R56,R49,R48,R14,R6,R5,R4,R3,R2,R1,","R_0805","libref","2","14","","",
"4.7K","desc","R84,R45,R13,R12,R11,R10,R9,R8,R7,","R_0805","libref","2","9","","",
"100","desc","R86,R85,R70,R65,R62,","R_0805","libref","2","5","","",
"120","desc","R87,","R_0805","libref","2","1","","",
"74HC04","desc","U1,","SOIC-14_150MIL","libref","14","1","","",
"SY8303","desc","U12,","TSOT-23-8_HandSoldering","libref","8","1","","",
"AZ1117-3.3","desc","U14,U13,","SOT-223","libref","4","2","","",
"LMV321","desc","U15,U10,U8,","SOT-23-5","libref","5","3","","",
"MAX3232","desc","U16,","SOIC-16_150MIL","libref","16","1","","",
"TJA1042T","desc","U17,","SOIC-8_150MIL","libref","8","1","","",
"STM32F407VETx","desc","U2,","LQFP-100_14X14X05P","libref","100","1","","",
"LMV358","desc","U5,","SOIC-8_150MIL","libref","8","1","","",
"LMV324","desc","U6,U4,U7,U3,","SOIC-14_150MIL","libref","14","4","","",
"ICL7660","desc","U9,","SOIC-8_150MIL","libref","8","1","","",
"12MHz","desc","Y1,","Crystal_SMD_3225-4pin_3.2x2.5mm","libref","4","1","","",
"Through Hole Items ",
"Conn_02x20_Odd_Even","desc","J3,","Socket_Strip_Straight_2x20_Pitch2.54mm","libref","40","1","","",
"GND","desc","SC8,SC7,SC6,SC5,SC4,SC3,SC2,SC1,","M3_Screwhole","libref","7","8","","",
"Buzzer","desc","BZ1,","Buzzer_12x9.5RM7.6","libref","2","1","","",
"10u","desc","C42,","CP_Radial_D5.0mm_P2.50mm","libref","2","1","","",
"25V 47uF","desc","C51,C46,","CP_Radial_D5.0mm_P2.50mm","libref","2","2","","",
"Conn_01x02","desc","J11,J12,J10,J7,J6,","JST_XH_B02B-XH-A_02x2.50mm_Straight","libref","2","5","","",
"Conn_01x02","desc","J15,J13,J18,J16,J14,","Pin_Header_Straight_1x02_Pitch2.54mm","libref","2","5","","",
"Conn_01x04","desc","J17,J5,","JST_XH_B04B-XH-A_04x2.50mm_Straight","libref","4","2","","",
"Barrel_Jack_Switch","desc","J19,","BARREL_JACK","libref","3","1","","",
"Conn_01x08","desc","J2,J1,","JST_XH_B08B-XH-A_08x2.50mm_Straight","libref","8","2","","",
"CAN","desc","J20,","JST_XH_B02B-XH-A_02x2.50mm_Straight","libref","2","1","","",
"Conn_01x04","desc","J4,","Pin_Header_Straight_1x04_Pitch2.54mm","libref","4","1","","",
"Conn_01x06","desc","J9,J8,","JST_XH_B06B-XH-A_06x2.50mm_Straight","libref","6","2","","",
"Fan","desc","M2,M1,","JST_XH_B02B-XH-A_02x2.50mm_Straight","libref","2","2","","",
"10K","desc","RV1,","3362P","libref","3","1","","",
"PC817","desc","U11,","DIP-4","libref","4","1","","",

## KiCad design Power/HallEffectSampling/power.kicad_pcb

Parts:
C1: 1nF; 0805_C
C2, C12: 1uF; 0805_C
C3: 104 100V; 1206_C
C4, C5: 100V 4.7uF; 1210_C
C6, C10: 104; 0805_C
C7: 6.8pF NP0; 0805_C
C8: 3.3nF NP0; 0805_C
C9: 10nF; 0805_C
C11: 100uF 16V; CP_Elec_6.3x5.8
C13: 103; 0805_C
C14: 100uF 100V; CP_Radial_D10.0mm_P5.00mm
D1: ZMM4758 56V; LL-41
D2: SK310; SMC(DO-214AB)_S1
D3: LED; LED_0805
D4: D_TVS; SMAF_S5
F1: 500mA; 1206_R
FB1: 1K; 1206_R
J1, J6, J7: GND; PCB-10B-M4
J3: 50V in; PCB-10B-M4
J5: Conn_01x04; JST_XH_B04B-XH-A_04x2.50mm_Straight
J8: Conn_01x04; PhoenixContact_MC-G_04x3.81mm_Angled
L1: 120uH 3A; L_12.6mm_13.5mm
Q1: 2N5551; SOT-23(SOT-23-3)
Q2: SUP90P06; TO-220-External_Thermal_Mount
R1: 47K; 0805_R
R2: 2.2K; 0805_R
R3, R16, R20: 10K; 0805_R
R4: 10k; 0805_R
R5, R10, R14, R18: 100K; 0805_R
R6: R_Small; 0805_R
R7: 33k; 0805_R
R8: 0; 0805_R
R9: 1M; 0805_R
R11: 3.3K; 0805_R
R15: 330K; 0805_R
R17: 1K; 0805_R
R19: 33K; 0805_R
SC1, SC2: GND; M3_Screwhole
U1: L78L05_SOT89; SOT-89(SOT-89-3)
U2: OP07; SOIC-8_150MIL
U3: TPS54160; MSOP-10-1EP_W3mm
U4: ACS758xCB-100U-PFF; Allegro_CB_PFF

Connections:
50Vin: F1.2, Q2.3 (S), R1.1, R4.1, U4.5 (IP-)
50Vout: Q2.2 (D)
+5V: C2.1, C6.2, R16.1, R17.2, U1.1 (OUT), U2.7 (V+), U4.1 (VCC)
+12V: C11.1, C12.1, J8.1, J8.2, L1.2, R18.1, U1.3 (IN)
Earth: C1.1, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C11.2, C12.2, C13.1, C14.2, D1.2 (A2), D2.1 (A), D4.1 (A1), J1.1, J5.4, J6.1, J7.1, J8.3, J8.4, Q1.2 (E), R2.2, R6.1, R9.1, R11.2, R15.2, R20.2, SC1.1, SC2.1, U1.2 (GND), U2.4 (V-), U3.9 (GND), U3.11 (Thermal), U4.2 (GND)
Im_sense: J5.2, R8.1, U2.6
unnamed: C1.2, Q1.1 (B), R3.1, R5.2, R6.2
unnamed: C3.1, C4.1, C5.1, FB1.1, R10.1, U3.2 (VIN)
unnamed: C7.1, R14.1, U3.8 (COMP)
unnamed: C8.1, R14.2
unnamed: C9.1, U3.4 (SS)
unnamed: C10.1, D2.2 (K), L1.1, U3.10 (PH)
unnamed: C10.2, U3.1 (BOOT)
unnamed: C14.1, D4.2 (A2), J3.1, U4.4 (IP+)
unnamed: D1.1 (A1), F1.1, FB1.2
unnamed: D3.1 (K), R16.2, U3.6 (PWRGD)
unnamed: D3.2 (A), R17.1
unnamed: Q1.3 (C), R7.2
unnamed: Q2.1 (G), R4.2, R5.1, R7.1
unnamed: R8.2, R9.2, U2.2 (-)
unnamed: R10.2, R11.1, U3.3 (EN)
unnamed: R15.1, U3.5 (RT)
unnamed: R18.2, R19.1
unnamed: R19.2, R20.1, U3.7 (Vsense)
PWR_on: J5.3, R3.2
VImain: C13.2, U2.3 (+), U4.3 (VIOUT)
Vm_sense: J5.1, R1.2, R2.1

Notes on the sheet:
GND from the Power Supply
50V from the Power Supply
TEST
Vm_sense = 0.0447 * Vmain
20mV/A

Board: 2 copper layers, 95.0 x 48.0 mm, 53 parts (0 on the bottom side), 26 nets.

File Power/HallEffectSampling/power_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"1nF","desc","C1,","0805_C","libref","2","1","","",
"104","desc","C10,C6,","0805_C","libref","2","2","","",
"100uF 16V","desc","C11,","CP_Elec_6.3x5.8","libref","2","1","","",
"1uF","desc","C12,C2,","0805_C","libref","2","2","","",
"103","desc","C13,","0805_C","libref","2","1","","",
"104 100V","desc","C3,","1206_C","libref","2","1","","",
"100V 4.7uF","desc","C5,C4,","1210_C","libref","2","2","","",
"6.8pF NP0","desc","C7,","0805_C","libref","2","1","","",
"3.3nF NP0","desc","C8,","0805_C","libref","2","1","","",
"10nF","desc","C9,","0805_C","libref","2","1","","",
"60V","desc","D1,","SMB(DO-214AA)_S5","libref","2","1","","",
"SK310","desc","D2,","SMC(DO-214AB)_S1","libref","2","1","","",
"LED","desc","D3,","LED_0805","libref","2","1","","",
"500mA","desc","F1,","1206_R","libref","2","1","","",
"1K","desc","FB1,","1206_R","libref","2","1","","",
"120uH 3A","desc","L1,","L_12.6mm_13.5mm","libref","2","1","","",
"2N5551","desc","Q1,","SOT-23(SOT-23-3)","libref","3","1","","",
"SUP90P06","desc","Q2,","TO-220-External_Thermal_Mount","libref","3","1","","",
"47K","desc","R1,","0805_R","libref","2","1","","",
"3.3K","desc","R11,","0805_R","libref","2","1","","",
"330K","desc","R15,","0805_R","libref","2","1","","",
"1K","desc","R17,","0805_R","libref","2","1","","",
"100K","desc","R18,R14,R10,R5,","0805_R","libref","2","4","","",
"33K","desc","R19,","0805_R","libref","2","1","","",
"2.2K","desc","R2,","0805_R","libref","2","1","","",
"10K","desc","R20,R16,R3,","0805_R","libref","2","3","","",
"10k","desc","R4,","0805_R","libref","2","1","","",
"R_Small","desc","R6,","0805_R","libref","2","1","","",
"33k","desc","R7,","0805_R","libref","2","1","","",
"0","desc","R8,","0805_R","libref","2","1","","",
"1M","desc","R9,","0805_R","libref","2","1","","",
"L78L05_SOT89","desc","U1,","SOT-89(SOT-89-3)","libref","4","1","","",
"OP07","desc","U2,","SOIC-8_150MIL","libref","8","1","","",
"TPS54160","desc","U3,","MSOP-10-1EP_W3mm","libref","11","1","","",
"Through Hole Items ",
"50V in","desc","J3,","PCB-10B-M4","libref","2","1","","",
"Conn_01x04","desc","J5,","JST_XH_B04B-XH-A_04x2.50mm_Straight","libref","4","1","","",
"GND","desc","J7,J6,J1,","PCB-10B-M4","libref","2","3","","",
"Conn_01x04","desc","J8,","PhoenixContact_MC-G_04x3.81mm_Angled","libref","4","1","","",
"GND","desc","SC2,SC1,","M3_Screwhole","libref","7","2","","",
"ACS758xCB-100B-PFF","desc","U4,","Allegro_CB_PFF","libref","37","1","","",

## KiCad design Interface/interface.kicad_pcb

Parts:
C1, C2, C3, C4, C8, C12: 102; 0805_C
C5: 104; 1206_C
C6: 10uF; 0805_C
C7, C13, C14, C17, C19: 104; 0805_C
C9, C18: 10uF; 1206_C
C10, C15: 103; 0805_C
C11: 20p; 0805_C
C16: 1uF; 0805_C
D1, D5, D6: 1N4148; LL-34
D2, D3, D4: LED; LED_D3.0mm_Horizontal_O6.35mm_Z10.0mm
FB1: Ferrite_Bead_Small; 0805_L
J1: RS232 CAT; PhoenixContact_MC-G_04x3.81mm_Angled
J2: DR9_Dual_Male; DR9
J3: CIV out; PhoenixContact_MC-G_02x3.81mm_Angled
J4, J6, J8, J10: AudioJack_PJ325; PJ325
J5: RF sense; PhoenixContact_MC-G_02x3.81mm_Angled
J7: ALC trig; PhoenixContact_MC-G_02x3.81mm_Angled
J9: +3.3V; PhoenixContact_MC-G_02x3.81mm_Angled
L1, L2, L3, L4, L5, L6, L7, L8, L9: 1uH; 0805_L
Q1: 8050; SOT-23(SOT-23-3)
Q2: MMBT5401; SOT-23(SOT-23-3)
Q3: MMBT5551; SOT-23(SOT-23-3)
R1, R17: 10K; 0805_R
R2: 4.7K; 0805_R
R3, R4, R5, R11, R12, R13, R18: 1K; 0805_R
R6, R9: --; 0805_R
R7, R10, R21, R22: 2.2K; 0805_R
R8, R20: 100; 0805_R
R14, R23: 0; 0805_R
R15: 10k; 0805_R
R16, R19: 47K; 0805_R
RV1: 10K; Potentiometer_Trimmer_Bourns_3296W
SC1, SC2: Conn_01x01; M3_Screwhole
U1: ICL7660; SOIC-8_150MIL
U2: LMV321; SOT-23-5
U3: TL431; SOT-23(SOT-23-3)

Connections:
/ALC_plugged: D3.1 (A), J6.2, R10.1
/BAND_CIV: C8.2, J3.1, L6.1, Q1.3 (C), R2.2
/CIV_plugged: D2.1 (A), J4.2, R21.2
/COMPUTER_RXD232: C3.1, J1.3, L1.1, L5.1
/COMPUTER_TXD232: C1.1, J1.2, L4.1
/PTT_RTS: C2.1, J1.1, L3.1
/VRef: D5.1 (A), RV1.2, U2.1 (+)
CAT232_IN: C4.1, L2.1, R1.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.1, C9.2, C12.1, C13.1, C14.2, C15.1, C16.1, C17.2, C18.2, C19.1, D1.1 (A), D2.2 (K), D3.2 (K), D6.2 (K), J1.4, J2.0 (PAD), J2.5, J2.15, J3.2, J4.1, J4.3, J5.2, J6.1, J6.3, J7.2, J8.1, J9.2, J10.1, Q1.2 (E), Q3.2 (E), R6.2, R7.2, R9.2, R12.2, R15.1, R19.2, R23.2, SC1.1, SC2.1, U1.3 (GND), U3.3 (A), U3.6 (A), U3.7 (A)
unnamed: C6.1, U1.2 (CAP+)
unnamed: C6.2, U1.4 (CAP-)
unnamed: C7.1, C9.1, U1.5 (VOUT), U2.2 (V-)
unnamed: C10.1, C11.2, R3.1
unnamed: C10.2, R5.2, R7.1, U2.4
unnamed: C11.1, C12.2, R3.2, R4.1, R6.1, U2.3 (-)
unnamed: C13.2, D6.1 (A), L7.1, R5.1
unnamed: C14.1, R8.2, R9.1, U2.5 (V+)
unnamed: C15.2, D5.2 (K), L8.2
unnamed: C16.2, R11.2, R13.2, R14.2, U3.2 (K)
unnamed: D1.2 (K), Q1.1 (B), R1.2
unnamed: D4.1 (A), R22.1
unnamed: D4.2 (K), J8.5, L9.2
unnamed: FB1.1, J9.1
unnamed: J2.2, L1.2
unnamed: J2.3, L4.2
unnamed: J2.7, L3.2
unnamed: J2.12, L2.2
unnamed: J2.13, L5.2
unnamed: J4.5, L6.2
unnamed: J5.1, R4.2
unnamed: J6.5, L7.2
unnamed: J7.1, L8.1
unnamed: J10.5, R20.1
unnamed: Q2.2 (E), R16.2, R17.1
unnamed: Q2.3 (C), R18.1
unnamed: Q3.1 (B), R18.2, R19.1
unnamed: Q3.3 (C), R20.2
unnamed: R11.1, RV1.1
unnamed: R12.1, RV1.3
unnamed: R14.1, R15.2, U3.1 (REF)
unnamed: R23.1, U1.6 (LV)
PTT: C19.2, L9.1, Q2.1 (B), R16.1
VCC: C5.1, C17.1, C18.1, FB1.2, R2.1, R8.1, R10.2, R13.1, R17.2, R21.1, R22.2, U1.8 (V+)

Notes on the sheet:
Back Panel
Control
Yaesu CAT
ICOM CI-V
ALC
PTT
PTT out
Low effective
Lower
Upper
Direct Cable
Cross Cable

Board: 2 copper layers, 100.0 x 50.0 mm, 77 parts (0 on the bottom side), 43 nets.

File Interface2/interface_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"20p","desc","C11,","0805_C","libref","2","1","","",
"102","desc","C12,C8,C4,C3,C2,C1,","0805_C","libref","2","6","","",
"103","desc","C15,C10,","0805_C","libref","2","2","","",
"1uF","desc","C16,","0805_C","libref","2","1","","",
"104","desc","C19,C17,C14,C13,C7,","0805_C","libref","2","5","","",
"104","desc","C5,","1206_C","libref","2","1","","",
"10uF","desc","C6,","0805_C","libref","2","1","","",
"10uF","desc","C9,C18,","1206_C","libref","2","2","","",
"1N4148","desc","D6,D5,D1,","LL-34","libref","2","3","","",
"Ferrite_Bead_Small","desc","FB1,","0805_L","libref","2","1","","",
"1uH","desc","L9,L8,L7,L6,L5,L4,L3,L2,L1,","0805_L","libref","2","9","","",
"8550","desc","Q2,","SOT-23(SOT-23-3)","libref","3","1","","",
"8050","desc","Q3,Q1,","SOT-23(SOT-23-3)","libref","3","2","","",
"10K","desc","R1,","0805_R","libref","2","1","","",
"1K","desc","R13,R12,R11,R5,R3,","0805_R","libref","2","5","","",
"10k","desc","R15,","0805_R","libref","2","1","","",
"R_Small","desc","R19,R18,R17,R16,R6,R4,","0805_R","libref","2","6","","",
"4.7K","desc","R2,","0805_R","libref","2","1","","",
"100","desc","R20,","0805_R","libref","2","1","","",
"2.2K","desc","R22,R21,R10,R7,","0805_R","libref","2","4","","",
"0","desc","R23,R14,R9,R8,","0805_R","libref","2","4","","",
"ICL7660","desc","U1,","SOIC-8_150MIL","libref","8","1","","",
"LMV321","desc","U2,","SOT-23-5","libref","5","1","","",
"TL431","desc","U3,","SOT-23(SOT-23-3)","libref","3","1","","",
"Through Hole Items ",
"LED","desc","D4,D3,D2,","LED_D3.0mm_Horizontal_O6.35mm_Z10.0mm","libref","2","3","","",
"RS232 CAT","desc","J1,","PhoenixContact_MC-G_04x3.81mm_Angled","libref","4","1","","",
"AudioJack_PJ325","desc","J10,J8,J6,J4,","PJ325","libref","5","4","","",
"DR9_Dual_Male","desc","J2,","DR9","libref","22","1","","",
"CIV out","desc","J3,","PhoenixContact_MC-G_02x3.81mm_Angled","libref","2","1","","",
"RF sense","desc","J5,","PhoenixContact_MC-G_02x3.81mm_Angled","libref","2","1","","",
"ALC trig","desc","J7,","PhoenixContact_MC-G_02x3.81mm_Angled","libref","2","1","","",
"+5V","desc","J9,","PhoenixContact_MC-G_02x3.81mm_Angled","libref","2","1","","",
"10K","desc","RV1,","Potentiometer_Trimmer_Bourns_3296W","libref","3","1","","",
"Conn_01x01","desc","SC2,SC1,","M3_Screwhole","libref","7","2","","",
