# Repository LuZening/OPA1000 (continued)

## KiCad design RF/Directional_Coupler/Directional_coupler.kicad_pcb

Board: 2 copper layers, 60.0 x 67.5 mm, 58 parts (0 on the bottom side), 32 nets.

Parts:
C1, C2, C3, C4, C5, C7, C8, C9, C10, C11, C13, C14, C15: 104; R_0805
C6, C12: 1uF; R_0805
C16, C17: 10uF; R_0805
D1, D2, D3, D4: 1N4148; SOD-123
D5: SS14; SMA(DO-214AC)_S1
J1: RF in; RF_conn_pad
J2: RF out; RF_conn_pad
J3: Singal; JST_XH_B06B-XH-A_06x2.50mm_Straight
R1, R15: 10; R_0805
R2, R3: 430; R_1206
R4, R9, R12, R13, R16, R18: 100; R_0805
R5, R8: 68; R_0805
R6, R7: 56 2W; R_2512
R10, R14: 1M; R_0805
R11, R17: 1K; R_0805
SC1, SC2, SC3, SC4: GND; M3_Screwhole
T1, T1#2: 30T; 5943004901
T2, T2#2: 1T; 5943004901
U1, U5: LMH6609MF; SOT-23-5
U2, U6: LMV358; SOIC-8_150MIL
U3, U4: AD8307; SOIC-8_150MIL
U7: AMS1117-3.3; SOT-89(SOT-89-3)

Connections:
+3V3: C2.2, C7.2, C11.2, C14.2, C17.1, R1.1, R15.1, U1.5, U2.8, U5.5, U6.8, U7.2
+5V: D5.1, J3.6
FWD: J3.4, R16.1
FWD_peak: J3.5, R9.1
GND: C1.1, C2.1, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C11.1, C12.2, C13.1, C14.1, C15.1, C16.2, C17.2, J1.2, J2.2, J3.1, R5.1, R6.2, R7.2, R8.1, R10.1, R14.1, SC1.1, SC2.1, SC3.1, SC4.1, U1.2, U2.4, U3.2, U4.2, U5.2, U6.4, U7.1
unnamed: C1.2, R1.2, U4.6, U4.7
unnamed: C3.1, R2.2, R5.2
unnamed: C3.2, U3.1
unnamed: C4.1, U4.8
unnamed: C4.2, R3.1, R8.2
unnamed: C5.1, U1.3, U2.5, U3.4
unnamed: C6.1, R4.1, R10.2, U2.3
unnamed: C8.2, U3.8
unnamed: C9.1, U4.1
unnamed: C10.1, U4.4, U5.3, U6.5
unnamed: C12.1, R12.2, R14.2, U6.3
unnamed: C13.2, R15.2, U3.6, U3.7
unnamed: C15.2, C16.1, D5.2, U7.3
unnamed: D1.1, D2.2, U1.1
unnamed: D1.2, R4.2
unnamed: D2.1, R11.2, U1.4
unnamed: D3.1, D4.2, U5.1
unnamed: D3.2, R12.1
unnamed: D4.1, R17.1, U5.4
unnamed: R2.1, R6.1
unnamed: R3.2, R7.1
unnamed: R9.2, R11.1, U2.1, U2.2
unnamed: R13.1, R17.2, U6.1, U6.2
unnamed: R16.2, U2.6, U2.7
unnamed: R18.1, U6.6, U6.7
REV: J3.2, R18.2
REV_peak: J3.3, R13.2

## KiCad design RF/Directional_Coupler_Linear/Directional_coupler.kicad_pcb

Board: 2 copper layers, 60.0 x 67.5 mm, 61 parts (0 on the bottom side), 31 nets.

Parts:
C1: 10p 1KV; 1206_C
C2, C4, C8, C14, C16: 104; 0805_C
C3, C15: 1uF; 0805_C
C5, C6, C12, C13: 10nF; 0805_C
C7, C11: 103; 0805_C
C9, C10: 10uF; 0805_C
D1, D2, D3, D7, D8, D9: 1N4148; SOD-123
D4, D6: BAT54S; SOT-23(SOT-23-3)
D5: SD123; SOD-123
J1: RF in; RF_conn_pad
J2: Singal; JST_XH_S06B-XH-A_06x2.50mm_Angled
J3: RF out; RF_conn_pad
L1, L2: 10uH; 0805_L
R1, R2, R3, R16, R17, R18: 100; 0805_R
R4, R14: 1K; R_0805
R5, R15: 1M; R_0805
R6, R13: 4.7K; R_0805
R7, R12: 100; 1206_R
R8, R11: 330; 1206_R
R9, R10: 56 2W; R_2512
SC1, SC2, SC3, SC4: GND; M3_Screwhole
T1, T1#2: 1T; 5943004901
T2, T2#2: 33T; 5943004901
U1, U5: LMV358; SOIC-8_150MIL
U2, U4: LMH6609MF; SOT-23-5
U3: AZ1117-3.3; SOT-89(SOT-89-3)

Connections:
+3V3: C2.2, C4.2, C10.1, C14.2, C16.2, D3.2, D7.2, U1.8, U2.5, U3.2, U4.5, U5.8
+5V: D5.1, J2.1
FWD: J2.3, R1.1
FWD_peak: J2.2, R2.1
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C8.1, C9.2, C10.2, C12.1, C13.2, C14.1, C15.2, C16.1, D4.1, D6.1, J1.2, J2.6, J3.2, R5.1, R6.1, R7.1, R9.2, R10.2, R12.1, R13.1, R15.1, SC1.1, SC2.1, SC3.1, SC4.1, U1.4, U2.2, U3.1, U4.2, U5.4
unnamed: C1.2, J1.1
unnamed: C3.1, R3.1, R5.2, U1.3
unnamed: C5.2, D3.1, L1.1, U1.5, U2.3
unnamed: C6.2, D4.2, L1.2, R6.2
unnamed: C7.1, R7.2, R8.2
unnamed: C7.2, D4.3
unnamed: C8.2, C9.1, D5.2, U3.3
unnamed: C11.1, D6.3
unnamed: C11.2, R11.1, R12.2
unnamed: C12.2, D6.2, L2.1, R13.2
unnamed: C13.1, D7.1, L2.2, U4.3, U5.5
unnamed: C15.1, R15.2, R16.2, U5.3
unnamed: D1.1, D2.2, U2.1
unnamed: D1.2, R3.2
unnamed: D2.1, R4.2, U2.4
unnamed: D8.1, R14.1, U4.4
unnamed: D8.2, D9.1, U4.1
unnamed: D9.2, R16.1
unnamed: R1.2, U1.6, U1.7
unnamed: R2.2, R4.1, U1.1, U1.2
unnamed: R8.1, R9.1
unnamed: R10.1, R11.2
unnamed: R14.2, R17.1, U5.1, U5.2
unnamed: R18.1, U5.6, U5.7
REV: J2.5, R18.2
REV_peak: J2.4, R17.2

File RF/Directional_Coupler_Linear/Directional_coupler_BOM.csv:

"Comment","Description","Designator","Footprint","LibRef","Pins","Quantity","PartNumber","url",
"10p 1KV","desc","C1,","1206_C","libref","2","1","","",
"10uF","desc","C10,C9,","0805_C","libref","2","2","","",
"103","desc","C11,C7,","0805_C","libref","2","2","","",
"10nF","desc","C13,C12,C6,C5,","0805_C","libref","2","4","","",
"1uF","desc","C15,C3,","0805_C","libref","2","2","","",
"104","desc","C16,C14,C8,C4,C2,","0805_C","libref","2","5","","",
"SD123","desc","D5,","SOD-123","libref","2","1","","",
"BAT54S","desc","D6,D4,","SOT-23(SOT-23-3)","libref","3","2","","",
"1N4148","desc","D9,D8,D7,D2,D3,D1,","SOD-123","libref","2","6","","",
"10uH","desc","L2,L1,","0805_L","libref","2","2","","",
"56 2W","desc","R10,R9,","R_2512","libref","2","2","","",
"330","desc","R11,R8,","1206_R","libref","2","2","","",
"100","desc","R12,R7,","1206_R","libref","2","2","","",
"1M","desc","R15,R5,","R_0805","libref","2","2","","",
"100","desc","R16,R18,R17,R3,R2,R1,","0805_R","libref","2","6","","",
"1K","desc","R4,R14,","R_0805","libref","2","2","","",
"4.7K","desc","R6,R13,","R_0805","libref","2","2","","",
"1T","desc","T1,T1,","5943004901","libref","0","2","","",
"33T","desc","T2,T2,","5943004901","libref","0","2","","",
"AZ1117-3.3","desc","U3,","SOT-89(SOT-89-3)","libref","4","1","","",
"LMH6609MF","desc","U4,U2,","SOT-23-5","libref","5","2","","",
"LMV358","desc","U5,U1,","SOIC-8_150MIL","libref","8","2","","",
"Through Hole Items ",
"RF in","desc","J1,","RF_conn_pad","libref","39","1","","",
"Singal","desc","J2,","JST_XH_S06B-XH-A_06x2.50mm_Angled","libref","6","1","","",
"RF out","desc","J3,","RF_conn_pad","libref","39","1","","",
"GND","desc","SC4,SC3,SC2,SC1,","M3_Screwhole","libref","7","4","","",

## KiCad design RF/OPA1000_RF/RF_input/RF_input.kicad_pcb

Board: 2 copper layers, 50.0 x 100.0 mm, 48 parts (0 on the bottom side), 21 nets.

Parts:
C1, C2, C3, C4, C4#2, C5: 104; 0805
C6, C7: 102; C_1206_HandSoldering
D1: 1N4007; SMA(DO-214AC)_S1
J1: +12V; PCB-35-M3
J2: GND; PCB-35-M3
J3: In; RF_conn_pad
Q1: BLF188XR
Q2: 2N3904; TO-92-SMD
R1: 2.2K; 0805
R2: 200; 0805
R3: 2K; 0805
R4: 10; 0805
R5: 220k; 0805
R6: 8.2K; 0805
R7: 1k; 0805
R8: 1.8K; 0805
R9: 10K; 0805
R10: 5.6K; 0805
R11: 1K; 0805
R12, R21: 10 1W; R_2512_HandSoldering
R13: 22 1/2W; R_1812_HandSoldering
R14, R15, R16, R17: 240 1W; R_2512_HandSoldering
R18, R19: 100 1W; R_2512_HandSoldering
R20: 0; 0805
R22: 0; R_1206_HandSoldering
RV1: 2.2k; Potentiometer_Trimmer_Bourns_3224W
SC1, SC2, SC3, SC4, SC5, SC6: Screw; M3_Screwhole
SW1: SW_SPDT; R_0805_HandSoldering
T1: 28B0562-100
TP1: TestPoint; Measurement_Point_Round-SMD-Pad_Big
U1: LM358; SOIC-8_150MIL
U2: TL431; SOT-23(SOT-23-3)

Connections:
+12V: C1.1, D1.2, R1.2, R8.1, U1.8
/K: R1.1, R2.1, RV1.1, U2.2
G1: Q1.3, R12.2, R18.2, R19.2
G2: Q1.4, R18.1, R19.1, R21.2
GND: C1.2, C2.2, C3.2, C5.2, J2.1, Q2.1, R5.2, R7.2, R9.2, R11.2, R20.1, SC1.1, SW1.2, U1.4, U2.3
GNDPWR: C4.2, C4#2.2, C6.2, C7.2, J3.2, R14.1, R15.1, R16.1, R17.1, R20.2, SC2.1, SC3.1, SC4.1, SC5.1, SC6.1
unnamed: C2.1, R5.1, RV1.2, SW1.1, U1.3
unnamed: C3.1, R3.1, R6.2, U1.5
unnamed: C4.1, C4#2.1, R22.2
unnamed: C5.1, Q2.3, R6.1, R8.2, R10.1
unnamed: C6.1, R12.1
unnamed: C7.1, R21.1
unnamed: D1.1, J1.1
unnamed: J3.1, R13.2
unnamed: Q2.2, R10.2, R11.1
unnamed: R2.2, R9.1, U2.1
unnamed: R3.2, U1.1, U1.2
unnamed: R4.2, U1.6, U1.7
unnamed: R7.1, RV1.3
unnamed: R13.1, R14.2, R15.2, R16.2, R17.2
Vbias: R4.1, R22.1, TP1.1

## KiCad design RF/Attenuator/Attenuator/Attenuator.kicad_pcb

Parts:
J1, J2: Conn_01x01; M3_Screwhole
J3: RF out; N-KY_PCB_EDGE_MOUNT_SMA-KWE
J4: RF in; N-KY_PCB_EDGE_MOUNT_SMA-KWE
R1: 100 50W; TO-220-2_External_Thermal_Mount_Short
R2: 75 30W; TO-220-2_External_Thermal_Mount_Short
R3: 100 30W; TO-220-2_External_Thermal_Mount_Short

Connections:
GND: J1.1, J2.1, J3.2 (Ext), J4.2 (Ext), R1.1, R3.2
unnamed: J3.1 (In), R2.2, R3.1
unnamed: J4.1 (In), R1.2, R2.1

Board: 2 copper layers, 7 parts (0 on the bottom side), 3 nets, no tracks yet.

## Code that names these connections

File Code/OPA1000_controller.ioc (part):

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Mcu.Name=STM32F407V(E-G)Tx
Mcu.Package=LQFP100
Mcu.UserName=STM32F407VETx
PA0-WKUP.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PA0-WKUP.GPIO_Label=MCU_STATE_LED
PA0-WKUP.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PA0-WKUP.GPIO_PuPd=GPIO_PULLUP
PA0-WKUP.PinState=GPIO_PIN_SET
PA0-WKUP.Signal=GPIO_Output
PA1.GPIOParameters=GPIO_PuPd,GPIO_Label
PA1.GPIO_Label=BAND
PA1.GPIO_PuPd=GPIO_PULLDOWN
PA1.Signal=GPIO_Input
PA10.GPIOParameters=GPIO_Speed
PA10.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PA11.GPIO_Label=ALC_cancel
PA11.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PA11.GPIO_PuPd=GPIO_PULLUP
PA11.PinState=GPIO_PIN_SET
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_PuPd,GPIO_Label
PA12.GPIO_Label=Transmit
PA12.GPIO_PuPd=GPIO_PULLDOWN
PA12.Signal=GPIO_Input
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_PuPd,GPIO_Label
PA15.GPIO_Label=TEMP2_HIGH
PA15.GPIO_PuPd=GPIO_PULLDOWN
PA15.Signal=GPIO_Input
PA2.GPIOParameters=GPIO_Speed
PA2.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Signal=ADCx_IN3
PA4.Signal=ADCx_IN4
PA5.Signal=ADCx_IN5
PA6.Signal=ADCx_IN6
PA7.Signal=ADCx_IN7
PA8.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PA8.GPIO_Label=CLEAR_FAULT
PA8.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PA8.GPIO_PuPd=GPIO_NOPULL
PA8.PinState=GPIO_PIN_SET
PA8.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Speed
PA9.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.Signal=ADCx_IN8
PB1.Signal=ADCx_IN9
PB10.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB10.GPIO_Label=LCD_BL
PB10.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB10.GPIO_PuPd=GPIO_PULLUP
PB10.Signal=GPIO_Output
PB11.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PB11.GPIO_Label=T_INT
PB11.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PB11.GPIO_PuPd=GPIO_PULLUP
PB11.Signal=GPXTI11
PB12.GPIOParameters=GPIO_Speed
PB12.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB12.Mode=CAN_Activate
PB12.Signal=CAN2_RX
PB13.GPIOParameters=GPIO_Speed
PB13.GPIO_Speed=GPIO_SPEED_FREQ_HIGH
PB13.Mode=CAN_Activate
PB13.Signal=CAN2_TX
PB3.GPIOParameters=GPIO_Speed
PB3.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI1_SCK
PB4.GPIOParameters=GPIO_Speed
PB4.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI1_MISO
PB5.GPIOParameters=GPIO_Speed
PB5.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI1_MOSI
PB6.GPIOParameters=GPIO_PuPd,GPIO_Label
PB6.GPIO_Label=REV2_HIGH
PB6.GPIO_PuPd=GPIO_PULLDOWN
PB6.Signal=GPIO_Input
PB7.GPIOParameters=GPIO_PuPd,GPIO_Label
PB7.GPIO_Label=REV1_HIGH
PB7.GPIO_PuPd=GPIO_PULLDOWN
PB7.Signal=GPIO_Input
PB8.GPIOParameters=GPIO_PuPd,GPIO_Label
PB8.GPIO_Label=T_BUSY
PB8.GPIO_PuPd=GPIO_PULLDOWN
PB8.Signal=GPIO_Input
PB9.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PB9.GPIO_Label=T_CS
PB9.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PB9.GPIO_PuPd=GPIO_PULLUP
PB9.PinState=GPIO_PIN_SET
PB9.Signal=GPIO_Output
PC0.Signal=ADCx_IN10
PC1.Signal=ADCx_IN11
PC10.GPIOParameters=GPIO_PuPd,GPIO_Label
PC10.GPIO_Label=TEMP1_HIGH
PC10.GPIO_PuPd=GPIO_PULLDOWN
PC10.Signal=GPIO_Input
PC11.GPIOParameters=GPIO_PuPd,GPIO_Label
PC11.GPIO_Label=IMAIN_HIGH
PC11.GPIO_PuPd=GPIO_PULLDOWN
PC11.Signal=GPIO_Input
PC12.GPIOParameters=GPIO_PuPd,GPIO_Label
PC12.GPIO_Label=VMAIN_HIGH
PC12.GPIO_PuPd=GPIO_PULLDOWN
PC12.Signal=GPIO_Input
PC13-ANTI_TAMP.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PC13-ANTI_TAMP.GPIO_Label=BAND_SEL1
PC13-ANTI_TAMP.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PC13-ANTI_TAMP.GPIO_PuPd=GPIO_PULLUP
PC13-ANTI_TAMP.PinState=GPIO_PIN_SET
PC13-ANTI_TAMP.Signal=GPIO_Output
PC14-OSC32_IN.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PC14-OSC32_IN.GPIO_Label=BAND_SEL_AUTO
PC14-OSC32_IN.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PC14-OSC32_IN.GPIO_PuPd=GPIO_PULLUP
PC14-OSC32_IN.PinState=GPIO_PIN_SET
PC14-OSC32_IN.Signal=GPIO_Output
PC2.Signal=ADCx_IN12
PC3.Signal=ADCx_IN13
PC4.Signal=ADCx_IN14
PC6.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PC6.GPIO_Label=LCD_RST
PC6.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PC6.GPIO_PuPd=GPIO_PULLUP
PC6.PinState=GPIO_PIN_SET
PC6.Signal=GPIO_Output
PC8.Signal=GPIO_Input
PD0.Mode=16b-d1
PD0.Signal=FSMC_D2
PD1.Mode=16b-d1
PD1.Signal=FSMC_D3
PD10.Mode=16b-d1
PD10.Signal=FSMC_D15
PD13.GPIOParameters=GPIO_PuPd,GPIO_Speed_High_Default,GPIO_Label
PD13.GPIO_Label=LCD_RS
PD13.GPIO_PuPd=GPIO_PULLUP
PD13.GPIO_Speed_High_Default=GPIO_SPEED_FREQ_VERY_HIGH
PD13.Mode=A18_1
PD13.Signal=FSMC_A18
PD14.Mode=16b-d1
PD14.Signal=FSMC_D0
PD15.Mode=16b-d1
PD15.Signal=FSMC_D1
PD2.GPIOParameters=GPIO_Label
PD2.GPIO_Label=FAN1
PD2.Signal=GPIO_Output
PD3.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PD3.GPIO_Label=FAN2
PD3.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PD3.GPIO_PuPd=GPIO_NOPULL
PD3.Signal=GPIO_Output
PD4.GPIOParameters=GPIO_Label
PD4.GPIO_Label=LCD_RD
PD4.Mode=Lcd1
PD4.Signal=FSMC_NOE
PD5.GPIOParameters=GPIO_Label
PD5.GPIO_Label=LCD_WR
PD5.Mode=Lcd1
PD5.Signal=FSMC_NWE
PD6.GPIOParameters=GPIO_Speed
PD6.GPIO_Speed=GPIO_SPEED_FREQ_MEDIUM
PD6.Mode=Asynchronous
PD6.Signal=USART2_RX
PD7.GPIOParameters=GPIO_PuPd,GPIO_Label
PD7.GPIO_Label=LCD_CS
PD7.GPIO_PuPd=GPIO_PULLUP
PD7.Mode=NorPsramChipSelect1_1
PD7.Signal=FSMC_NE1
PD8.Mode=16b-d1
PD8.Signal=FSMC_D13
PD9.Mode=16b-d1
PD9.Signal=FSMC_D14
PE0.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PE0.GPIO_Label=PWR_on_sig
PE0.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PE0.GPIO_PuPd=GPIO_PULLUP
PE0.PinState=GPIO_PIN_SET
PE0.Signal=GPIO_Output
PE10.Mode=16b-d1
PE10.Signal=FSMC_D7
PE11.Mode=16b-d1
PE11.Signal=FSMC_D8
PE12.Mode=16b-d1
PE12.Signal=FSMC_D9
PE13.Mode=16b-d1
PE13.Signal=FSMC_D10
PE14.Mode=16b-d1
PE14.Signal=FSMC_D11
PE15.Mode=16b-d1
PE15.Signal=FSMC_D12
PE2.GPIOParameters=PinState,GPIO_Label,GPIO_ModeDefaultOutputPP
PE2.GPIO_Label=BAND_SEL6
PE2.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PE2.PinState=GPIO_PIN_SET
PE2.Signal=GPIO_Output
PE3.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PE3.GPIO_Label=BAND_SEL5
PE3.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PE3.GPIO_PuPd=GPIO_PULLUP
PE3.PinState=GPIO_PIN_SET
PE3.Signal=GPIO_Output
PE4.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PE4.GPIO_Label=BAND_SEL4
PE4.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PE4.GPIO_PuPd=GPIO_PULLUP
PE4.PinState=GPIO_PIN_SET
PE4.Signal=GPIO_Output
PE5.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PE5.GPIO_Label=BAND_SEL3
PE5.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PE5.GPIO_PuPd=GPIO_PULLUP
PE5.PinState=GPIO_PIN_SET
PE5.Signal=GPIO_Output
PE6.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PE6.GPIO_Label=BAND_SEL2
PE6.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PE6.GPIO_PuPd=GPIO_PULLUP
PE6.PinState=GPIO_PIN_SET
PE6.Signal=GPIO_Output
PE7.Mode=16b-d1
PE7.Signal=FSMC_D4
PE8.Mode=16b-d1
PE8.Signal=FSMC_D5
PE9.Mode=16b-d1
PE9.Signal=FSMC_D6
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=12000000
RCC.SYSCLKFreq_VALUE=120000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File Code/Src/Sensor_task.c (part):

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//
// ADC1_3: FWD1 forward power 1
uint32_t FWD1_raw;
int FWD1 = 0; // Unit 1 Watt

// ADC1_4: FWDpeak1 forward power 1 peak value
uint32_t FWDpeak1_raw;
int FWDpeak1 = 0; // Unit 1 Watt

// ADC1_5: REVpeak1 reverse power 1 peak value
uint32_t REVpeak1_raw;
int REVpeak1 = 0;

// ADC1_6: REV1 reverse power 1 peak value

uint32_t REV1_raw;
int REV1 = 0;

// ADC1_7:FWD2

uint32_t FWD2_raw;
int FWD2 = 0;

// ADC1_8: FWDpeak2

uint32_t FWDpeak2_raw;
int FWDpeak2 = 0;

// ADC1_9: REVpeak2

uint32_t REVpeak2_raw;
int REVpeak2 = 0;

// ADC1_14: REV2

uint32_t REV2_raw;
int REV2 = 0;

// ADC3 channel order
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
// ADC3_12: Temperature1
uint32_t Temp1_raw;
int Temp1 = 0; // core temperature to 0.1C

// ADC3_13: Temperature2
uint32_t Temp2_raw;
int Temp2 = 0; // ambient to 0.1C

PeakDetector PD_Vmain;
PeakDetector PD_Imain;
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
## Commit log

2019-12-12 Create
2020-02-08 Controller Circuit Done. Now routing
2020-02-10 routing
2020-02-13 MCU routed
2020-02-26 Power module
2022-01-28 first
2022-04-04 Adapted for LVGL PC simulator with LVGL_SIM macro Refurbished GUI appearance, resolved alignment problems
2022-04-04 OPA2000 Project created
2022-04-04 Fixed OPA2000 project compile errors Removed lv_obj_set_style_local_pad_all, which is not supported by old version of LVGL
2022-04-13 Added support for rotary encoders. Added interactable widgets to lv_groups
2022-04-17 Fixed known bugs of group control. Optimized the color scheme of selected buttons.
2024-10-22 OPA1000 and 2000 compatibility
2024-10-22 cleared project for OPA1000 compatibility
2024-10-24 modified Alert logic
2025-05-05 before modification for OPA2000 amp
2025-10-19 fix OPA1000 BAND RX
